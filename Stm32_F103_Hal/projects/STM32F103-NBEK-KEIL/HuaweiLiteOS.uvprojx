# Keil uVision project HuaweiLiteOS.uvprojx, settings and files
target HuaweiLiteOS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HuaweiLiteOS +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F10X_MD,STM32F103xB,RAM_SIZE_LEVEL_1,LOS_STM32F103
  c include: ..\..\kernel\base\include;..\..\kernel\include;..\..\kernel\cpu\arm\cortex-m3;..\..\kernel\config;..\..\kernel\cmsis;..\..\kernel\link\keil;..\..\platform\STM32F103_NBEK;..\..\platform\STM32F103_NBEK\Inc;..\..\platform\STM32F103_NBEK\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\platform\STM32F103_NBEK\Drivers\STM32F1xx_HAL_Driver\Inc\Legacy;..\..\platform\STM32F103_NBEK\Drivers\CMSIS\Include;..\..\platform\STM32F103_NBEK\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\api\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xd000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: ..\..\platform\STM32F103_NBEK\STM32F1xx-LiteOS.sct
  group kernel
    ../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../kernel/base/mem/: los_membox.c los_memory.c los_memstat.c los_multipledlinkhead.c
    ../../kernel/base/misc/: los_misc.c
  group cpu/m3
    ../../kernel/cpu/arm/cortex-m3/: los_hw.c los_hw_tick.c los_hwi.c los_dispatch_keil.s
  group config
    ../../kernel/config/: los_config.c
  group cmsis
    ../../kernel/cmsis/: cmsis_liteos.c
  group platform/stm32f103
    ../../platform/STM32F103_NBEK/: los_bsp_adapter.c stm32f1xx_nbek.c los_bsp_uart.c los_bsp_led.c
  group platform/stm32f103/driver
    ../../platform/STM32F103_NBEK/Src/: usart.c gpio.c
  group api
    ../../api/Src/: los_nbiot_entry.c los_led_entry.c
  group driver/cmsis
    ../../platform/STM32F103_NBEK/Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group driver/stm32f103_hal_driver
    ../../platform/STM32F103_NBEK/Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group startup
    ../../platform/STM32F103_NBEK/: los_startup_keil.s
  group user
    ../../user/: main.c
